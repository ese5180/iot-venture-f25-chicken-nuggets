## zephyr_app/tests/PIR_UNIT_TEST/testcase.yaml
```yaml
tests:
  pir.test:
    platform_allow: qemu_cortex_m3
    tags: pir unit
    harness: ztest
```
